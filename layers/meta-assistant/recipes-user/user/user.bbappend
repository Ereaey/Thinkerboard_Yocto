INHERIT += "extrausers"

EXTRA_USERS_PARAMS = "useradd -P assistant-ps assistant;"
EXTRA_USERS_PARAMS += "usermod  -P linux  root;" 
